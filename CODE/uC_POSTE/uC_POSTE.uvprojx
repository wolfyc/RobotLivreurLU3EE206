# Keil uVision project uC_POSTE.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uC_POSTE
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c include: ..\uC_POSTE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: DTMF.h DTMF.C main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
